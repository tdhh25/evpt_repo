# Keil uVision project Temperature_Project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Temperature_Project +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,__CHECK_DEVICE_DEFINES
  c include: ..\Source_Files\Inc;..\Hal_Drivers\STM32F4xx_HAL_Driver\Inc;..\Hal_Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\CMSIS\Device\ST\STM32F4xx\Include;..\CMSIS\Include;..\Start_File;..\Source_Files\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Source_Files
    ../Source_Files/Src/: ads1263.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c SP3485EN.c dwin_com.c dwin_config.c dwin_driver.c ring_buffer.c AT24C256.c
  group Include_Files
    ../Source_Files/Inc/: ADS1262_Interface.h ads1263.h main.h stm32f4xx_hal_conf.h stm32f4xx_it.h SP3485EN.h dwin_com.h dwin_driver.h dwin_config.h dwin_types.h ring_buffer.h AT24C256.h
  group StartUp_File
    ../Start_File/: startup_stm32f405xx.s
  group HAL_Driver
    ../Hal_Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
